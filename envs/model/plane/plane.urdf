Commit message: 3

File: envs/model/plane/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 10; visual mesh filename=plane.obj scale=1 1 0.1
